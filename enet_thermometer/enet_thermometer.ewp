# IAR project enet_thermometer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm; PART_LM3S8962
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ; ..\..\..; ..\..\..\inc; ..\..\..\driverlib; ..\common; uip-1.0\uip; uip-1.0\apps\httpd
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: enet_thermometer.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\StellarisWare\examples\myCortex-LM8962_work\common\myCortex-LM8962.icf
  ILINK.IlinkProgramEntryLabel: ResetISR
configuration Bootloader (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..; ..\..\..\inc; ..\..\..\driverlib; ..\common
  ILINK.IlinkIcfFile: C:\StellarisWare\examples\myCortex-LM8962_work\common\myCortex-LM8962_bootloader.icf
  group Common
    ../common/: llio.c startup_ewarm.c
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    uip-1.0/apps/httpd/: httpd.c
    uip-1.0/uip/: uip.c uip_arp.c
  group Source
    ./: enet_thermometer.c

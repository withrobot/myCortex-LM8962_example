# IAR project i2c_myARS-USB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm; PART_LM3S8962
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..; ..\..\..\inc; ..\..\..\driverlib; ..\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: i2c_myARS-USB.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\StellarisWare\examples\myCortex-LM8962_work\common\myCortex-LM8962.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Bootloader (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: C:\StellarisWare\examples\myCortex-LM8962_work\common\myCortex-LM8962_bootloader.icf
  group Common
    ../common/: llio.c startup_ewarm.c
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ./: i2c_myARS-USB.c

# IAR project pwm_ccp_dimming.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm; PART_LM3S8962
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..; ..\..\..\inc; ..\..\..\driverlib; ..\common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: pwm_ccp_dimming.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\StellarisWare\examples\myCortex-LM8962_work\common\myCortex-LM8962.icf
  ILINK.IlinkProgramEntryLabel: ResetISR
configuration Bootloader (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: C:\StellarisWare\examples\myCortex-LM8962_work\common\myCortex-LM8962_bootloader.icf
  group Common
    ../common/: startup_ewarm.c
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ./: pwm_ccp_dimming.c

# IAR project boot_loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S8962
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..; ..\..\..\boot_loader
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: boot_loader.bin
  ILINK.IlinkOutputFile: boot_serial.out
  ILINK.IlinkIcfFile: ..\..\..\boot_loader\bl_link.icf
  ILINK.IlinkProgramEntryLabel: ResetISR
  group Source
    ../../../boot_loader/: bl_autobaud.c bl_can.c bl_check.c bl_decrypt.c bl_enet.c bl_flash.c bl_i2c.c bl_main.c bl_packet.c bl_ssi.c bl_startup_ewarm.S bl_uart.c bl_usb.c bl_usbfuncs.c

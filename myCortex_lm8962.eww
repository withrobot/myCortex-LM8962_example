<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\adc_2ch\adc_2ch.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\adc_temperature\adc_temperature.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\blinky\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\boot_loader\boot_loader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\encoder\encoder.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio\gpio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gpio_interrupt\gpio_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\printf_scanf\printf_scanf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pwm\pwm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pwm_dimming\pwm_dimming.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\systick\systick.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\timer\timer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart_echo\uart_echo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart_echo_interrupt\uart_echo_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart_myARS-USB\uart_myARS-USB.ewp</path>
  </project>
  <batchBuild/>
</workspace>


